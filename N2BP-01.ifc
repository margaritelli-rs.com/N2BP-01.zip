Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [ContentGUID: , VersionGUID: a28aabce-41b2-43fe-a382-48aa9a2aee79, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Coordinate condivise]
File name: N2BP-01.ifc
Time: 2025-10-19T13:10:34+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.80.30 (ITA) - IFC 23.4.1.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey: Livello:Livello 1, Livello 1
LongName: Livello 1; Elevation: 0 mm
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello 1; ID tipo: 1899; Tipo: Livello 1
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: Livello 1; Piano edificio: yes; Strutturale: no
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello 1

# IfcRailing: N2BP-01_R23:N2BP-01_R23, N2BP-01_R23:N2BP-01_R23:16886
In: Livello 1
Type - Material: Metal, wood, <Unnamed>
Type - Altro - Categoria: Ringhiere: Supporti; Nome famiglia: N2BP-01_R23
Type - Costruzione - Altezza: 125 mm
Type - Dati identità - Acciaio CAM Strade: conforme; altezza lama (cm): 66; altezza tot (cm): 110; ASI: 1; CAD layer: n.a.; certificato art 14 comma 22: TOCUSTOMIZE; certificato CE: TOCUSTOMIZE; certificato di corretta posa: TOCUSTOMIZE; Classe: N2; classe intrusione del veicolo: n.a.; classe larghezza di lavoro: W4; cordolo: rialzato 125 mm; Costo: 240; deflessione dinamica (m): 0,9; Descrizione: (colore); documentazione integrativa (url): TOCUSTOMIZE; DOP: TOCUSTOMIZE; DSM: n.a.; EPD: sì; GWP totale cradle to gate: 7,49 kgCO2eq/m; infissione (m): n.a.; interasse (m): 3; intrusione del veicolo (m): n.a.; larghezza di lavoro (m): 1,1; larghezza max (cm): 32; lavorazione aggiuntiva: TOCUSTOMIZE; Legno CAM Strade: CoC PEFC; livello di severità: A; lunghezza minima (m): 78; manuale di installazione: TOCUSTOMIZE; Materiale: Acciaio S355J0WP e Legno lamellare GL24H; Modello: N2BP-01; N° Certificato CE: CPR/0491/5649; Nome del tipo: N2BP-01_R23; Norma di riferimento: EN 1317-2 e EN1317-5; Prezzo di Capitolato: 240; Prodotto: Barriera di sicurezza stradale; Produttore: Margaritelli Road Safety; progressiva iniziale: TOCUSTOMIZE; resoconti di prova: TOCUSTOMIZE; supporto: fondazione cls; testata su arginello: n.a.; Tipologia: N2 Bordo Ponte; Unità di Misura: m; URL: https://margaritelli-rs.com/it/products/n2bp-01/; URL (certificati CE, DOP, manuali, schede tecniche, schemi): https://margaritelli-rs.com/it/products/n2bp-01/
Type - Pset_ManufacturerTypeInformation - Manufacturer: Margaritelli Road Safety
Pset_QuantityTakeOff - Reference: N2BP-01_R23
Pset_RailingCommon - Reference: N2BP-01_R23; IsExternal: no
Altro - Basement: yes; Bordo_Dx: yes; Bordo_Sx: yes; Famiglia: N2BP-01_R23; Famiglia e tipo: N2BP-01_R23: N2BP-01_R23; ID tipo: 16870; Tipo: N2BP-01_R23
Vincoli - Gioco mano: 0 mm; Host: Livello : Livello 1; Livello: Livello 1; Offset da host: 0 mm; Sposta con gli elementi più vicini: no
Quote - Area: 12.1379 m2; Volume: 0.703417 m3
